require xorg-app-common.inc
DESCRIPTION = "adjust backlight brightness using RandR extension"
DEPENDS += " libxrender libxrandr"
LIC_FILES_CHKSUM = "file://COPYING;md5=202066beded64bba09876a54f2dd2b65"

SRC_URI[md5sum] = "c9891d6a3f3129d56cede72daa0ba26c"
SRC_URI[sha256sum] = "af2f02d09de8a19848e3f3b322320141bceebf9d4097b7bd505457a1bd936509"


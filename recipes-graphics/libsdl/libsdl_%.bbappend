CFLAGS = "-Wall -Wextra -Wshadow -g -Os"

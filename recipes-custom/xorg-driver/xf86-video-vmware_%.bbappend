PACKAGECONFIG = "vmwgfx"


RDEPENDS_wiper = "bash gawk coreutils"

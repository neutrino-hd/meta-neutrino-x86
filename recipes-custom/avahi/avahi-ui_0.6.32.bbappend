

AVAHI_GTK = "gtk"

FILES_${PN}-dev_append = "/usr/include \
" 



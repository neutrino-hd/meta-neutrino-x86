FILES_${PN} = "*"
FILES_${PN}-examples = "${bindir}/* ${datadir}/cogl/examples-data/*"
FILES_libcogl = ""
FILES_libcogl-gles2 = ""
FILES_libcogl-pango = ""

FILES_libcogl-path = ""

do_install_append() {
	rm ${D}/etc/environment
}

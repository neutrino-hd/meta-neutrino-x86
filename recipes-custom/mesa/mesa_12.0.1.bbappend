PACKAGECONFIG_append += "gallium gallium-llvm dri3 r600 xa" 

MESA_LLVM_RELEASE = "3.6.0"

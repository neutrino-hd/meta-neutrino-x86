
X11TOOLS = "\
    fstests \
    x11perf \
    xrestop \
    xwininfo \
    xprop \
    xvideo-tests \
    "

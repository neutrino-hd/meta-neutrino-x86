
do_compile_prepend() {
        export GIR_EXTRA_LIBS_PATH="${B}/pango/.libs"
}
